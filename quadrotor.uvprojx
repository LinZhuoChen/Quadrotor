# Keil uVision project quadrotor.uvprojx, settings and files
target group (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: quadrotor
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Algorithm;.\App;.\Basement;.\Core;.\Sensor;.\Readme;.\User
  asm include: .\Algorithm;.\App;.\Basement;.\Core;.\Sensor;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group hardware-isolates
    ./Sensor/: sonar.c px4.c mpu6050.c
    ./App/: measure_time.c
    ./Basement/: led.c delay.c exti.c iic.c iic2.c pwm.c receive.c timer.c usart.c
  group hardware-core
    ./Core/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c startup_stm32f10x_md.s
  group algorithm-math
    ./Algorithm/: cordic.c quad_math.c
  group algorithm-core
    ./Algorithm/: ekf.c imu.c pid.c rotate.c
  group algorithm-data
    ./Algorithm/: data.c
  group software-interface
    ./App/: motor.c bsp.c global.c app.c
  group software-applycation
    ./User/: main.c
